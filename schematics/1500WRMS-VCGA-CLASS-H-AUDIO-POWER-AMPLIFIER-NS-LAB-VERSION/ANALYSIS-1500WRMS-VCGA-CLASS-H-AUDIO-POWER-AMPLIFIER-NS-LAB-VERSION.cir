.title ANALYSIS OF 1500W RMS VCGA CLASS-H AUDIO POWER AMPLIFIER (LAB VERSION)
.include "spice_models/model.lib"
V1 M_VCCHP 0 120V DC
V2 0 M_VCCHN 120V DC
Rdummy1 M_OUT 0 4
V3 M_VCCLP 0 42V DC
V4 0 M_VCCLN 42V DC
V5 M_INPUT 0 dc 0 ac 1.41 sin(0 1.414 1k 0 0)
Q501 Net-_Q501-Pad1_ Net-_Q501-Pad2_ M_VCCHP 2N5401
D606 Net-_D606-Pad1_ M_VCCHP 1N4742
X6011 /POWER_AMP_BLOCK/M_VSWOP Net-_D606-Pad1_ M_VCCHP IRF9540
D605 M_VCCLP Net-_C601-Pad2_ 1N4148
R604 Net-_D604-Pad2_ Net-_Q602-Pad2_ 12k
R5126 Net-_Q5086-Pad3_ Net-_D601-Pad1_ 0.56
D607 M_VCCLP /POWER_AMP_BLOCK/M_VSWOP MURF1560
Q603 Net-_D606-Pad1_ Net-_Q603-Pad2_ M_VCCHP 2N5401
D604 Net-_C601-Pad1_ Net-_D604-Pad2_ 1N4148
Q602 Net-_Q602-Pad1_ Net-_Q602-Pad2_ M_VCCHP 2N5401
Q503 Net-_Q503-Pad1_ Net-_Q503-Pad2_ M_VCCHN 2N5551
X6021 /POWER_AMP_BLOCK/M_VSWON Net-_D613-Pad2_ M_VCCHN IRF540
D613 M_VCCHN Net-_D613-Pad2_ 1N4742
R613 Net-_D611-Pad1_ Net-_Q605-Pad2_ 12k
Q605 Net-_Q605-Pad1_ Net-_Q605-Pad2_ M_VCCHN 2N5551
D612 Net-_C602-Pad2_ M_VCCLN 1N4148
D611 Net-_D611-Pad1_ Net-_C602-Pad1_ 1N4148
Q606 Net-_D613-Pad2_ Net-_Q606-Pad2_ M_VCCHN 2N5551
D614 /POWER_AMP_BLOCK/M_VSWON M_VCCLN MURF1560
R5156 Net-_R5151-Pad1_ Net-_Q5116-Pad3_ 100
Q5116 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5116-Pad3_ 2SA1943
R5158 Net-_R5151-Pad1_ Net-_Q5118-Pad3_ 100
Q5118 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5118-Pad3_ 2SA1943
R5159 Net-_R5151-Pad1_ Net-_Q5119-Pad3_ 100
Q5119 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5119-Pad3_ 2SA1943
R51510 Net-_R5151-Pad1_ Net-_Q51110-Pad3_ 100
Q51110 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q51110-Pad3_ 2SA1943
Q5086 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5086-Pad3_ 2SC5200
R5146 Net-_Q5086-Pad3_ Net-_R5141-Pad2_ 100
Q5088 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5088-Pad3_ 2SC5200
R5148 Net-_Q5088-Pad3_ Net-_R5141-Pad2_ 100
Q5089 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5089-Pad3_ 2SC5200
R5149 Net-_Q5089-Pad3_ Net-_R5141-Pad2_ 100
Q50810 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q50810-Pad3_ 2SC5200
R51410 Net-_Q50810-Pad3_ Net-_R5141-Pad2_ 100
R51210 Net-_Q50810-Pad3_ Net-_D601-Pad1_ 0.56
R5129 Net-_Q5089-Pad3_ Net-_D601-Pad1_ 0.56
R5128 Net-_Q5088-Pad3_ Net-_D601-Pad1_ 0.56
R51310 Net-_D601-Pad1_ Net-_Q51110-Pad3_ 0.56
R5139 Net-_D601-Pad1_ Net-_Q5119-Pad3_ 0.56
R5138 Net-_D601-Pad1_ Net-_Q5118-Pad3_ 0.56
R5136 Net-_D601-Pad1_ Net-_Q5116-Pad3_ 0.56
R517 Net-_D601-Pad1_ Net-_Q512-Pad2_ 820
D510 /POWER_AMP_BLOCK/M_VBIASP Net-_D510-Pad2_ 1N4148
Q512 Net-_D510-Pad2_ Net-_Q512-Pad2_ Net-_D601-Pad1_ 2N5551
Q506 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_VBIASP /POWER_AMP_BLOCK/M_DRV1P MJE15032
R5141 Net-_Q5081-Pad3_ Net-_R5141-Pad2_ 100
R5125 Net-_Q5085-Pad3_ Net-_D601-Pad1_ 0.56
R5124 Net-_Q5084-Pad3_ Net-_D601-Pad1_ 0.56
R5123 Net-_Q5083-Pad3_ Net-_D601-Pad1_ 0.56
R5122 Net-_Q5082-Pad3_ Net-_D601-Pad1_ 0.56
R5121 Net-_Q5081-Pad3_ Net-_D601-Pad1_ 0.56
R519 Net-_D601-Pad1_ Net-_Q513-Pad2_ 820
Q513 Net-_D511-Pad1_ Net-_Q513-Pad2_ Net-_D601-Pad1_ 2N5401
D511 Net-_D511-Pad1_ /POWER_AMP_BLOCK/M_VBIASN 1N4148
Q509 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_VBIASN /POWER_AMP_BLOCK/M_DRV1N MJE15033
R5151 Net-_R5151-Pad1_ Net-_Q5111-Pad3_ 100
Q5111 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5111-Pad3_ 2SA1943
R5152 Net-_R5151-Pad1_ Net-_Q511-Pad3_ 100
Q511 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q511-Pad3_ 2SA1943
R5153 Net-_R5151-Pad1_ Net-_Q5113-Pad3_ 100
Q5113 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5113-Pad3_ 2SA1943
R5154 Net-_R5151-Pad1_ Net-_Q5114-Pad3_ 100
Q5114 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5114-Pad3_ 2SA1943
R5155 Net-_R5151-Pad1_ Net-_Q5115-Pad3_ 100
Q5115 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5115-Pad3_ 2SA1943
Q5082 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5082-Pad3_ 2SC5200
R5142 Net-_Q5082-Pad3_ Net-_R5141-Pad2_ 100
Q5083 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5083-Pad3_ 2SC5200
R5143 Net-_Q5083-Pad3_ Net-_R5141-Pad2_ 100
Q5084 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5084-Pad3_ 2SC5200
R5144 Net-_Q5084-Pad3_ Net-_R5141-Pad2_ 100
Q5085 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5085-Pad3_ 2SC5200
R5145 Net-_Q5085-Pad3_ Net-_R5141-Pad2_ 100
R5135 Net-_D601-Pad1_ Net-_Q5115-Pad3_ 0.56
R5134 Net-_D601-Pad1_ Net-_Q5114-Pad3_ 0.56
R5133 Net-_D601-Pad1_ Net-_Q5113-Pad3_ 0.56
R5132 Net-_D601-Pad1_ Net-_Q511-Pad3_ 0.56
R5131 Net-_D601-Pad1_ Net-_Q5111-Pad3_ 0.56
C501 /POWER_AMP_BLOCK/M_VBIASP /POWER_AMP_BLOCK/M_VBIASN 0.1uF
Q505 /POWER_AMP_BLOCK/M_VBIASP Net-_Q505-Pad2_ Net-_Q505-Pad3_ MJE340
R5092 /POWER_AMP_BLOCK/M_DRV1P /POWER_AMP_BLOCK/M_DRV1N 2.7k
R5091 /POWER_AMP_BLOCK/M_DRV1P /POWER_AMP_BLOCK/M_DRV1N 120
R503 0 Net-_Q503-Pad1_ 22k
R5042 Net-_Q503-Pad2_ M_VCCHN 680
R5041 Net-_Q503-Pad2_ M_VCCHN 150
R501 Net-_Q501-Pad1_ 0 22k
R5022 M_VCCHP Net-_Q501-Pad2_ 680
R5021 M_VCCHP Net-_Q501-Pad2_ 150
R5137 Net-_D601-Pad1_ Net-_Q5117-Pad3_ 0.56
R5127 Net-_Q5087-Pad3_ Net-_D601-Pad1_ 0.56
R5147 Net-_Q5087-Pad3_ Net-_R5141-Pad2_ 100
Q5087 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5087-Pad3_ 2SC5200
Q5117 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5117-Pad3_ 2SA1943
R5157 Net-_R5151-Pad1_ Net-_Q5117-Pad3_ 100
R51311 Net-_D601-Pad1_ Net-_Q51111-Pad3_ 0.56
R51211 Net-_Q50811-Pad3_ Net-_D601-Pad1_ 0.56
R51411 Net-_Q50811-Pad3_ Net-_R5141-Pad2_ 100
Q50811 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q50811-Pad3_ 2SC5200
Q51111 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q51111-Pad3_ 2SA1943
R51511 Net-_R5151-Pad1_ Net-_Q51111-Pad3_ 100
D608 Net-_D608-Pad1_ Net-_D601-Pad1_ 1N4738
R505 /POWER_AMP_BLOCK/M_VBIASP Net-_Q505-Pad2_ 820
R414 Net-_D401-Pad2_ M_VCCHN 22k
D503 Net-_D502-Pad2_ /POWER_AMP_BLOCK/M_VASOUT 1N4148
D502 Net-_D501-Pad2_ Net-_D502-Pad2_ 1N4148
D501 /POWER_AMP_BLOCK/M_VBIASP Net-_D501-Pad2_ 1N4148
D506 Net-_D505-Pad2_ /POWER_AMP_BLOCK/M_VBIASN 1N4148
D505 Net-_D504-Pad2_ Net-_D505-Pad2_ 1N4148
D504 /POWER_AMP_BLOCK/M_VASOUT Net-_D504-Pad2_ 1N4148
Q504 /POWER_AMP_BLOCK/M_VBIASN Net-_Q503-Pad1_ Net-_Q503-Pad2_ MJE340
Q502 /POWER_AMP_BLOCK/M_VBIASP Net-_Q501-Pad1_ Net-_Q501-Pad2_ MJE350
RT501 Net-_R507-Pad2_ Net-_D507-Pad1_ 5k
D507 Net-_D507-Pad1_ /POWER_AMP_BLOCK/M_VBIASN 1N4004
R4042 Net-_C403-Pad1_ /POWER_AMP_BLOCK/M_NFB 4.7k
R4041 Net-_C403-Pad1_ /POWER_AMP_BLOCK/M_NFB 300
C401 M_INPUT Net-_C401-Pad2_ 220uF
R4011 Net-_C401-Pad2_ /POWER_AMP_BLOCK/M_REF 300
Q404 Net-_Q404-Pad1_ Net-_Q403-Pad1_ Net-_Q403-Pad2_ MJE340
Q403 Net-_Q403-Pad1_ Net-_Q403-Pad2_ M_VCCHN 2N5551
R410 0 Net-_Q403-Pad1_ 22k
R4111 Net-_Q403-Pad2_ M_VCCHN 150
R4112 Net-_Q403-Pad2_ M_VCCHN 680
C403 Net-_C403-Pad1_ 0 220uF
R402 /POWER_AMP_BLOCK/M_REF 0 22k
C402 0 /POWER_AMP_BLOCK/M_REF 470pF
XRV401 Net-_R407-Pad1_ M_VCCHP Net-_R408-Pad1_ VR10K
R4051 M_VCCHP Net-_R4051-Pad2_ 470
R4061 M_VCCHP Net-_R4061-Pad2_ 470
R4062 Net-_R4061-Pad2_ Net-_C405-Pad1_ 22
R4052 Net-_R4051-Pad2_ Net-_C404-Pad1_ 22
R4012 Net-_C401-Pad2_ /POWER_AMP_BLOCK/M_REF 4.7k
Q401 Net-_C404-Pad1_ /POWER_AMP_BLOCK/M_REF Net-_Q401-Pad3_ 2N5551
Q402 Net-_C405-Pad1_ /POWER_AMP_BLOCK/M_NFB Net-_Q401-Pad3_ 2N5551
R507 Net-_Q505-Pad2_ Net-_R507-Pad2_ 4.7k
R508 Net-_Q505-Pad3_ Net-_D507-Pad1_ 180
R506 Net-_Q505-Pad2_ Net-_D507-Pad1_ 1.2k
Q407 Net-_Q407-Pad1_ Net-_D401-Pad2_ /POWER_AMP_BLOCK/M_VASIOUT MJE350
Q5081 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5081-Pad3_ 2SC5200
R403 Net-_D601-Pad1_ /POWER_AMP_BLOCK/M_NFB 22k
R409 Net-_Q401-Pad3_ Net-_Q404-Pad1_ 270
R408 Net-_R408-Pad1_ Net-_C405-Pad1_ 5.6k
R407 Net-_R407-Pad1_ Net-_C404-Pad1_ 5.6k
R520 Net-_D601-Pad1_ Net-_C502-Pad1_ 10
L501 Net-_D601-Pad1_ M_OUT 3uH
C502 Net-_C502-Pad1_ 0 0.1uF
X6022 /POWER_AMP_BLOCK/M_VSWON Net-_D613-Pad2_ M_VCCHN IRF540
X6012 /POWER_AMP_BLOCK/M_VSWOP Net-_D606-Pad1_ M_VCCHP IRF9540
R511 Net-_D601-Pad1_ /POWER_AMP_BLOCK/M_DRV2N 12
R510 /POWER_AMP_BLOCK/M_DRV2P Net-_D601-Pad1_ 12
Q510 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_DRV1N /POWER_AMP_BLOCK/M_DRV2N 2SA1943
R518 Net-_Q513-Pad2_ Net-_R5151-Pad1_ 10k
Q507 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV1P /POWER_AMP_BLOCK/M_DRV2P 2SC5200
R516 Net-_Q512-Pad2_ Net-_R5141-Pad2_ 10k
C602 Net-_C602-Pad1_ Net-_C602-Pad2_ 0.1uF
C601 Net-_C601-Pad1_ Net-_C601-Pad2_ 0.1uF
R612 Net-_D611-Pad1_ M_VCCHN 12k
R603 M_VCCHP Net-_D604-Pad2_ 12k
D601 Net-_D601-Pad1_ Net-_D601-Pad2_ 1N4738
D401 0 Net-_D401-Pad2_ 1N4004
D509 /POWER_AMP_BLOCK/M_VSWON /POWER_AMP_BLOCK/M_VBIASN 1N4004
D508 /POWER_AMP_BLOCK/M_VBIASP /POWER_AMP_BLOCK/M_VSWOP 1N4004
Q604 Net-_D611-Pad1_ Net-_D610-Pad1_ M_VCCLN 2N5401
R611 M_VCCLN Net-_D610-Pad1_ 33k
D610 Net-_D610-Pad1_ Net-_D609-Pad2_ 1N4007
Q601 Net-_D604-Pad2_ Net-_D603-Pad2_ M_VCCLP 2N5551
R602 Net-_D603-Pad2_ M_VCCLP 33k
D603 Net-_D602-Pad1_ Net-_D603-Pad2_ 1N4007
R601 M_VCCHP Net-_D602-Pad1_ 47k
R610 Net-_D609-Pad2_ M_VCCHN 47k
D602 Net-_D602-Pad1_ Net-_D601-Pad2_ 1N4004
D609 Net-_D608-Pad1_ Net-_D609-Pad2_ 1N4004
R622 Net-_D617-Pad2_ Net-_D603-Pad2_ 47k
D617 Net-_C603-Pad2_ Net-_D617-Pad2_ 1N4148
R621 M_VCCLP Net-_C603-Pad2_ 12k
D616 M_VCCLP Net-_C603-Pad2_ 1N4148
C603 Net-_C603-Pad1_ Net-_C603-Pad2_ 6.8nF
D615 /POWER_AMP_BLOCK/M_VSWOP Net-_C603-Pad1_ 1N4148
R4122 M_VCCHP Net-_Q405-Pad3_ 750
R4121 M_VCCHP Net-_Q405-Pad3_ 150
R4132 M_VCCHP Net-_Q406-Pad3_ 750
R4131 M_VCCHP Net-_Q406-Pad3_ 150
R4152 Net-_Q408-Pad2_ M_VCCHN 750
R4151 Net-_Q408-Pad2_ M_VCCHN 150
Q408 Net-_Q407-Pad1_ Net-_Q408-Pad2_ M_VCCHN 2N5551
C405 Net-_C405-Pad1_ /POWER_AMP_BLOCK/M_VASIOUT 120pF
Q406 /POWER_AMP_BLOCK/M_VASIOUT Net-_C405-Pad1_ Net-_Q406-Pad3_ MJE350
C404 Net-_C404-Pad1_ /POWER_AMP_BLOCK/M_VASOUT 120pF
Q405 /POWER_AMP_BLOCK/M_VASOUT Net-_C404-Pad1_ Net-_Q405-Pad3_ MJE350
Q409 /POWER_AMP_BLOCK/M_VASOUT Net-_Q407-Pad1_ Net-_Q408-Pad2_ MJE340
R620 Net-_C603-Pad1_ JH1 47k
R624 Net-_D620-Pad1_ Net-_D610-Pad1_ 47k
D620 Net-_D620-Pad1_ Net-_C604-Pad2_ 1N4148
D619 Net-_C604-Pad2_ M_VCCLN 1N4148
R623 M_VCCLN Net-_C604-Pad2_ 12k
C604 JH1 Net-_C604-Pad2_ 6.8nF
D618 JH1 /POWER_AMP_BLOCK/M_VSWON 1N4148
R605 Net-_Q602-Pad1_ M_VCCLP 68k
R606 Net-_Q602-Pad1_ Net-_Q603-Pad2_ 3.9k
R608 Net-_D606-Pad1_ Net-_C601-Pad2_ 220
R607 Net-_D606-Pad1_ Net-_C601-Pad1_ 20k
R617 Net-_C602-Pad2_ Net-_D613-Pad2_ 220
R614 M_VCCLN Net-_Q605-Pad1_ 68k
R615 Net-_Q605-Pad1_ Net-_Q606-Pad2_ 3.9k
R616 Net-_C602-Pad1_ Net-_D613-Pad2_ 20k
R618 M_VCCLN Net-_D613-Pad2_ 20k
R609 Net-_D606-Pad1_ M_VCCLP 20k
R619 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_VSWON 47k
.end
